# Keil uVision project CAN_Task_2.uvprojx, settings and files
target CAN_Task_2 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: CAN_Task_2 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F407xx,USE_STDPERIPH_DRIVER,__FPU_PRESENT = 1U,ARM_MATH_CM4,__CC_ARM,__TARGET_FPU_VFP
  c include: ../Core/Inc;                 ../Drivers/STM32F4xx_HAL_Driver/Inc;                 ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;                 ../Middlewares/Third_Party/FreeRTOS/Source/include;                 ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;                 ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;                 ../Drivers/CMSIS/Device/ST/STM32F4xx/Include;                 ../Drivers/CMSIS/Include;                 .\USER\Device;                 .\USER\Driver;                 .\USER\Protocal;                 .\USER\Tasks;                 .\USER\Algo;                 .\USER\Device_Motor;                 .\USER\Module;                 .\USER\Function;                 .\USER\Config;                 .\USER\Imu
  asm include: ..\Core\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c can.c dma.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_can.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Device
    ./USER/Device/: Motor.c rc.c rp_device.h imu_sensor.c vision_protocal.c vision_sensor.c judge_infantrypotocol.c judge_sensor.c Couple.c
  group Driver
    ./USER/Driver/: can_drv.c led_drv.c uart_drv.c rp_driver.h drv_haltick.c tim_drv.c
  group Protocal
    ./USER/Protocal/: can_protocal.c usart_protocal.c imu_protocol.c
  group Tasks
    ./USER/Tasks/: led_task.c heart_beat_task.c motor_ctrl_task.c imu_task.c gimbal_task.c shooting_task.c vision_task.c judge_task.c
  group Algo
    ./USER/Algo/: pid_algo.c rp_math.c crc.c
  group Device/Motor
    ./USER/Device_Motor/: Chassis_motor.c Gimbal_motor.c Shoot_motor.c
  group Module
    ./USER/Module/: Chassis.c State.c Shooting.c key.c
    ./USER/Config/: Gimbal.c
  group Function
    ./USER/Function/: S_function.c Auto.c Power_Limit.c
  group Config
    ./USER/Config/: rp_init.c motor_class.h
    ./: readme.txt
  group Imu
    ./USER/Imu/: bmi.c bmi2.c bmi2_common.c bmi2_ois.c bmi270.c bmi270_context.c soft_iic.c
software components: CMSIS:CORE 4.3.0, CMSIS:DSP 1.4.6
